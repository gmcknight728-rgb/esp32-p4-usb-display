## sdkconfig.defaults
```kconfig
# SPI configuration
CONFIG_SPI_MASTER_IN_IRAM=y

# LCD configuration
CONFIG_LCD_ENABLE_DEBUG_LOG=y

# FreeRTOS
CONFIG_FREERTOS_HZ=1000
```
